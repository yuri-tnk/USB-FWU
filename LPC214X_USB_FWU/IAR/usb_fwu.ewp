# IAR project usb_fwu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: fwu_lpc2146_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../usb_fwu/: fwu.c fwu_asm_iar.s79 fwu_init.c fwu_int.c fwu_queue.c fwu_usb_descr.c fwu_usb_ep.c fwu_usb_hw.c fwu_usb_req.c fwu_usb_thumb.c fwu_utils.c
    ./: fwu_startup_iar.s79 startup_hardware_init.s79
